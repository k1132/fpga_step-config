# Keil uVision project fpga_step_v10_arm.uvprojx, settings and files
target fpga_step_v10_arm (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: fpga_step_v10_arm
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --C99
  c include: ../Inc;     ../Middlewares/Third_Party/LwIP/src/include;     ../Middlewares/Third_Party/LwIP/system;     ../Drivers/STM32F4xx_HAL_Driver/Inc;     ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;     ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;     ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;     ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;     ../Middlewares/Third_Party/LwIP/src/include/lwip;     ../Middlewares/Third_Party/LwIP/src/include/lwip/apps;     ../Middlewares/Third_Party/LwIP/src/include/lwip/priv;     ../Middlewares/Third_Party/LwIP/src/include/lwip/prot;     ../Middlewares/Third_Party/LwIP/src/include/netif;     ../Middlewares/Third_Party/LwIP/src/include/netif/ppp;     ../Middlewares/Third_Party/LwIP/src/include/netif/ppp/polarssl;     ../Middlewares/Third_Party/LwIP/src/include/posix;     ../Middlewares/Third_Party/LwIP/src/include/posix/sys;     ../Middlewares/Third_Party/LwIP/system/arch;     ../Drivers/CMSIS/Include;    ../Middlewares/ST/STM32_USB_Host_Library/Core/Inc;    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ioreq.c usbd_ctlreq.c usbd_core.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Src/: usb_device.c
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_crc.c stm32f4xx_hal_pwr.c stm32f4xx_hal_flash.c stm32f4xx_hal_eth.c stm32f4xx_hal_rtc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_usb.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Application/User
    ../Src/: usbd_desc.c main.c usbd_conf.c usbd_cdc_if.c ethernetif.c stm32f4xx_it.c stm32f4xx_hal_msp.c lwip.c usbh_conf.c usb_host.c
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Middlewares/LwIP
    ../Middlewares/Third_Party/LwIP/src/core/: tcp_out.c tcp_in.c timeouts.c pbuf.c dns.c netif.c inet_chksum.c def.c udp.c raw.c tcp.c mem.c init.c ip.c sys.c stats.c memp.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv6/: inet6.c mld6.c ip6_frag.c dhcp6.c ip6_addr.c icmp6.c nd6.c ip6.c ethip6.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/: pppos.c magic.c ecp.c chap_ms.c ipv6cp.c fsm.c mppe.c utils.c ppp.c pppol2tp.c demand.c auth.c ccp.c lcp.c ipcp.c upap.c vj.c multilink.c chap-new.c pppapi.c eui64.c pppcrypt.c eap.c chap-md5.c pppoe.c
    ../Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4.c ip4_addr.c igmp.c icmp.c etharp.c autoip.c dhcp.c ip4_frag.c
    ../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md4.c md5.c arc4.c des.c sha1.c
    ../Middlewares/Third_Party/LwIP/src/api/: netifapi.c netdb.c sockets.c err.c netbuf.c tcpip.c api_lib.c api_msg.c
    ../Middlewares/Third_Party/LwIP/src/netif/: lowpan6.c slipif.c ethernet.c
  group Middlewares/USB_Host_Library
    ../Middlewares/ST/STM32_USB_Host_Library/Class/HID/Src/: usbh_hid_mouse.c usbh_hid_keybd.c usbh_hid_parser.c usbh_hid.c
    ../Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_pipes.c usbh_core.c usbh_ctlreq.c usbh_ioreq.c
software components: CMSIS:CORE 5.0.1
